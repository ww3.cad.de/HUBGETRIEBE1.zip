# Autodesk Inventor assembly: Hubgetriebe3
## iProperties
Created: 2008-10
Part Number: Hubgetriebe3
Document SubType Name: Assembly
Designer: nkrapf
Author: nkrapf
